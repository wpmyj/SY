# Keil uVision project SY.uvprojx, settings and files
target MASTER (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SY +hex
  AfterMake: fromelf --bin -o .\Bin\SYE_HMI0031(SYOR1.3.1.4)_160823.bin .\Objects\SY.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx,
  c include: ..\APP\INC;..\BSP\INC;..\UTILS\INC;..\KERNEL\INC;..\FWLIB\STM32F4xx_HAL_Driver\Inc;..\FWLIB\CMSIS\Device\ST\STM32F4xx\Include;..\FWLIB\CMSIS\Include;..\USER\INC;..\FWLIB\FatFs-0.12b\src;..\FWLIB\FatFs-0.12b\drivers;..\FWLIB\STM32_USB_Host_Library\Drivers;..\FWLIB\lwip-1.4.1\src\include;..\FWLIB\lwip-1.4.1\system;..\FWLIB\lwip-1.4.1\usr\INC;..\FWLIB\STM32_USB_Host_Library\Class\MSC\Inc;..\FWLIB\STM32_USB_Host_Library\Core\Inc;..\FWLIB\STM32_USB_Host_Library\Usr;..\FWLIB\STemWinLibrary532\inc;..\FWLIB\STemWinLibrary532\Usr;..\FWLIB\uCosIII-3.04.05\uC-BSP;..\FWLIB\uCosIII-3.04.05\uC-CPU;..\FWLIB\uCosIII-3.04.05\uC-CPU\ARM-Cortex-M4\RealView;..\FWLIB\uCosIII-3.04.05\uC-LIB;..\FWLIB\uCosIII-3.04.05\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\FWLIB\uCosIII-3.04.05\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\FWLIB\uCosIII-3.04.05\uCOS-III\Source;..\FWLIB\uCosIII-3.04.05\uC-Usr;..\FWLIB\DSP_LIB\Include;..\FWLIB\STM32_USB_Host_Library\Class\HID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group INC
    ../APP/INC/: app.h app_cfg.h App_GUI_Cfg.h App_Utils.h
    ../KERNEL/INC/: kernel.h
    ../BSP/INC/: bsp.h
    ../UTILS/INC/: utils.h fonts.h list.h
    ../USER/INC/: MY_DEBUG.H MY_ASSERT.H version.h config.h
    ../FWLIB/uCosIII-3.04.05/uC-Usr/: os_inc.h
  group USER
    ../USER/SRC/: main.c
  group APP
    ../APP/SRC/: System_Init.c app.c App_Utils.c App_DebugView.c App_Typewrite.c App_Menu.c App_SystemParameter.c App_TimeDate.c App_Language.c
  group KERNEL
    ../KERNEL/SRC/: kernel.c key.c io.c date.c mouse.c
  group BSP
    ../BSP/SRC/: bsp.c bsp_assert.c bsp_itm.c bsp_i2c_bus.c bsp_spi_bus.c bsp_fsmc_bus.c bsp_fatfs.c bsp_io.c bsp_timer.c bsp_uart.c bsp_pcf8563.c bsp_spi_flash.c bsp_lcd.c bsp_ra8875.c bsp_sdio_sd.c bsp_network.c
  group UTILS
    ../UTILS/SRC/: utils.c isqrt.c ustdlib.c ustring.c SeqList.c SeqQueue.c LinkQueue.c SeqStack.c LinkStack.c LinkSingleList.c LinkSingleCycleList.c LinkDoubleCycleList.c SeqListHash.c LinkSingleListHash.c SeqListSearch.c SeqListSort.c
  group LCD/Fonts
    ../FWLIB/FONTS/: asc12.c asc16.c
  group FatFs/Src
    ../FWLIB/FatFs-0.12b/src/: ffconf.h diskio.c ff.c
    ../FWLIB/FatFs-0.12b/src/option/: ccsbcs.c syscall.c
  group FatFs/Drivers
    ../FWLIB/FatFs-0.12b/drivers/: sd_diskio.c usbh_diskio.c ff_gen_drv.c file.c
  group USB_Host_Library/Usr
    ../FWLIB/STM32_USB_Host_Library/Usr/: usbh_conf.c usbh_usr.c
  group USB_Host_Library/Core
    ../FWLIB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group USB_Host_Library/MSC/Class
    ../FWLIB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group USB_Host_Library/HID/Class
    ../FWLIB/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group LwIP/Usr
    ../FWLIB/lwip-1.4.1/usr/SRC/: ethernetif.c UDP_Server.c TCP_Client.c
  group LwIP/Core
    ../FWLIB/lwip-1.4.1/src/core/: stats.c mem.c inet_chksum.c tcp.c sys.c raw.c tcp_out.c init.c pbuf.c dns.c lwip_timers.c def.c memp.c udp.c tcp_in.c netif.c
  group LwIP/Core/IPv4
    ../FWLIB/lwip-1.4.1/src/core/ipv4/: autoip.c igmp.c ip4_addr.c ip4.c dhcp.c icmp.c ip_frag.c
  group LwIP/Netif
    ../FWLIB/lwip-1.4.1/src/netif/: etharp.c
  group LwIP/Api
    ../FWLIB/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
  group emWin/Usr
    ../FWLIB/STemWinLibrary532/Usr/: GUIDRV.c GUIConf.c LCDConf.c emWinUtils.c
  group emWin/GUI_X
    ../FWLIB/STemWinLibrary532/OS/: GUI_X_OS.c
  group emWin/UC_Fonts
    ../FWLIB/STemWinLibrary532/GUI_UC/: GUI_UC_EncodeNone.c GUI_UC_FontConfig.c GUI_UC_X.c
  group emWin/Fonts
    ../FWLIB/STemWinLibrary532/fonts/: SongTiB_128X128.c ASCII_SongTi_8X16.c ASCII_SongTi_12X24.c ASCII_SongTi_16X32.c
  group emWin/Lib
    ../FWLIB/STemWinLibrary532/Lib/: STemWin532_CM4_OS_Keil.lib
  group emWin/PNG
    ../FWLIB/STemWinLibrary532/PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group uC/OS-III Usr
    ../FWLIB/uCosIII-3.04.05/uC-Usr/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h cpu_cfg.h lib_cfg.h
  group uC/OS-III BSP
    ../FWLIB/uCosIII-3.04.05/uC-BSP/: bsp_os.c cpu_bsp.c bsp_os.h
  group uC/OS-III CPU
    ../FWLIB/uCosIII-3.04.05/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../FWLIB/uCosIII-3.04.05/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/OS-III LIB
    ../FWLIB/uCosIII-3.04.05/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../FWLIB/uCosIII-3.04.05/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../FWLIB/uCosIII-3.04.05/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Ports
    ../FWLIB/uCosIII-3.04.05/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group DSP_LIB
    ../FWLIB/DSP_LIB/: arm_cortexM4lf_math.lib
  group CMSIS
    ../FWLIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../FWLIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../USER/SRC/: stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../USER/INC/: stm32f4xx_hal_conf.h
  group FWLIB
    ../FWLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sram.c stm32f4xx_hal_hcd.c
  group TEST
    ../TEST/unit/: board.c emWin.c uCos-III.c
  group Doc
    ../Doc/: Demo.c Demo.h
    ../: README.md
